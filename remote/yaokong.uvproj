# Keil uVision project yaokong.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0EFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
    ./src/: demo.c GPIO.c USART.C ADC.c delay.c NRF24L01.C spi.c 12864.c eInterrupt.c menu.c
